# Keil uVision project STM32F407_CAN_CMD.uvprojx, settings and files
target STM32F407_CAN_CMD (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F407_CAN_CMD +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../User/app;../User/control;../User/test;../User/extend;../User/lift;../User/gripper;../User/arm_rotate;../User/config;../User/motor;../User/chassis;../User/mecanum;../User/imu;../User/communication;../User/mission;../User/input;../User/servo;../User/turntable;../User/TJC;../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application
    ../Src/: main.c
  group User/app
    ../User/app/: app.c app.h
  group User/TJC
    ../User/TJC/: tjc.c tjc.h
  group User/mecanum
    ../User/mecanum/: mecanum.c mecanum.h
  group User/chassis
    ../User/chassis/: chassis.c chassis.h
  group User/motor
    ../User/motor/: motor.c motor.h emm42.c emm42.h
  group Device
    ../Src/: gpio.c tim.c can.c dma.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group User/communication
    ../User/communication/: raspberry.c raspberry.h task_code.c task_code.h
  group User/config
    ../User/config/: chassis_config.h servo_config.h turntable_config.h mission_config.h
  group User/control
    ../User/control/: heading_pid.c heading_pid.h
  group User/mission
    ../User/mission/: mission.c mission.h mission_action.c mission_action.h mission_route.c mission_route.h
  group User/input
    ../User/input/: button.c button.h
  group User/servo
    ../User/servo/: servo.c servo.h
  group User/gripper
    ../User/gripper/: gripper.c gripper.h
  group User/arm_rotate
    ../User/arm_rotate/: arm_rotate.c arm_rotate.h
  group User/lift
    ../User/lift/: lift.c lift.h
  group User/extend
    ../User/extend/: extend.c extend.h
  group User/test
    ../User/test/: test_gripper.c test_gripper.h test_lift.c test_lift.h test_extend.c test_extend.h test_servo1.c test_servo1.h test_servo2.c test_servo2.h test_mechanism.c test_mechanism.h test_chassis_control.c test_chassis_control.h test_chassis_position.c test_chassis_position.h test_chassis_move_distance.c test_chassis_move_distance.h test_heading.c test_heading.h
  group User/turntable
    ../User/turntable/: turntable.c turntable.h
  group User/imu
    ../User/imu/: hwt101.c hwt101.h
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_uart.c stm32f4xx_hal_can.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
software components: CMSIS:CORE 4.3.0
